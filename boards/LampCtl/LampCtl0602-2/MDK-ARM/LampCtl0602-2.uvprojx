# Keil uVision project LampCtl0602-2.uvprojx, settings and files
target LampCtl0602-2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LampCtl0602-2
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x10000
  c misc: --C99  --no-multibyte-chars
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver/Inc;..\..\..\..\chips\stm32f4xx\Driver/Inc/Legacy;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\arch\cortex-m\CMSIS\Device/ST/STM32F4xx/Include;..\..\..\..\libraries;..\..\..\..\libraries\mTMC5130Driver;..\..\..\..\libraries\Protocols;..\..\..\..\libraries\Driver;..\..\..\..\tools;..\..\..\..\libraries\Bus;..\..\..\..\Common;..\..\Src;..\..\..\..\kernel\F4_UCOSII;..\..\..\..\kernel;..\..\..\..\libraries\modules\itf;..\..\..\..\libraries\modules;..\..\..\board_mod;..\Inc
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ./: startup_stm32f407xx.s
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c voltage_cfg.c lampCtl.c
  group Drivers/ST
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c
  group Src
    ../../Src/: my_main.c my_callback.c gpio.c
    ../../../../tools/: delayus.c thread_safe.c math_util.c
    ../../../board_mod/: voltage.c
  group kernal
    ../../../../kernel/F4_UCOSII/: app_hooks.c F4_UCOS2.lib os_implement.c
  group tools
    ../../../../tools/: data_struct.c tool.c
    ../../../../libraries/Protocols/: bytesBuffer.c
  group modules
    ../../../../libraries/Boot/: firmwaeExcute.c
    ../../../../libraries/Bus/: bus.c
    ../../../../tools/: uart_byte_to_frame.c
    ../../../../libraries/Protocols/: protoTest.c IOHandle.c CommonHandle.c Protocols.c io_operation.c
    ../../../../libraries/modules/itf/: itf_00010000.c itf_00010010.c itf_00010020 .c itf_00010030 .c itf_00010031.c itf_00010032.c itf_00010040 .c itf_00010050.c itf_00010060.c itf_00010070.c itf_00010080.c itf_00010082.c itf_00070000.c itf_00070001.c itf_00070002.c itf_00070010.c itf_00070011.c itf_00070003.c
    ../../../../libraries/modules/: soft_iic.c
  group drivers
    ../../../../libraries/Bus/: CanDriverPB9.lib bus_can_f4_hal.c
    ../../../../tools/: flash_f4.c
software components: CMSIS:CORE 5.4.0
