# Keil uVision project MB0202-2A02.uvprojx, settings and files
target MB0202-2A02 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MB0202-2A02
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x10000
  c misc: --C99 --diag_suppress=1,177,550 --no-multibyte-chars
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\Inc\Legacy;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\chips\stm32f4xx\CMSISDevice\Inc;..\..\..\..\libraries\Protocols;..\..\..\..\libraries\Driver;..\..\..\..\tools;..\..\..\..\libraries\Bus;..\..\..\..\libraries;..\..\Src;..\..\..\..\kernel\F4_UCOSII;..\..\..\..\kernel;..\..\..\..\libraries\mTMC5130Driver;..\..\..\..\libraries\modules;..\..\..\..\libraries\modules\itf;..\..\..\..\libraries\drivers;..\..\..\board_mod
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ./: startup_stm32f407xx.s
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c motor_cfg.c motor_cmd_extend.c ad_signal_cfg.c io_thread_cfg.c rv_cfg.c mTMC5130Driver.c kalman.c
    ../Inc/: project_cfg.h
  group Drivers/ST
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Src
    ../../../../tools/: thread_safe.c async.c delayus.c
    ../../../board_mod/: motor_thread.c io_thread.c ad_signal.c rv_thread.c
    ../../Src/: my_main.c my_callback.c gpio.c ad5245.c
    ../../../../libraries/modules/itf/: itf_00010062.c
  group kernel
    ../../../../kernel/F4_UCOSII/: os_implement.c app_hooks.c F4_UCOS2.lib
  group drivers
    ../../../../libraries/Bus/: bus_can_f4_hal.c CanDriverPB9.lib
    ../../../../tools/: flash_f4.c
    ../../../../libraries/drivers/: runze_sv04_new.c
  group modules
    ../../../../libraries/modules/itf/: itf_00070010.c itf_00020010.c itf_00010000.c itf_00010010.c itf_00010020 .c itf_00010030 .c itf_00010031.c itf_00010040 .c itf_00010050.c itf_00010060.c itf_00010070.c itf_00010080.c itf_00010082.c itf_00010032.c itf_00010071.c itf_00010083.c itf_00070000.c itf_00070001.c itf_00070002.c itf_00070011.c itf_01000c10.c itf_00040000.c itf_00040010.c itf_00040020.c itf_00040030.c itf_00020030.c itf_00020000.c itf_00030000.c itf_01000c20.c itf_01000b04.c itf_000100a0.c itf_000100a1.c itf_000100a2.c itf_01000c50.c itf_01000c21.c itf_00040001.c itf_01000c23.c itf_00020001.c itf_00030001.c
    ../../../../libraries/Protocols/: protoTest.c CommonHandle.c bytesBuffer.c Protocols.c
    ../../../../tools/: data_struct.c
    ../../../../libraries/Bus/: bus.c
    ../../../../libraries/Boot/: firmwaeExcute.c
    ../../../../libraries/mTMC5130Driver/: mTMC5130Device.c
    ../../../../libraries/modules/: io_mod.c
  group tools
    ../../../../tools/: math_util.c tool.c
software components: CMSIS:CORE 5.4.0
