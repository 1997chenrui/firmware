# Keil uVision project MotorCtl-SG.uvprojx, settings and files
target MotorCtl-SG (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MotorCtl-SG
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x10000
  c misc: --C99 --no-multibyte-chars
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\Inc\Legacy;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\chips\stm32f4xx\CMSISDevice\Inc;..\..\..\..\libraries\Protocols;..\..\..\..\libraries\Driver;..\..\..\..\tools;..\..\..\..\libraries\Bus;..\..\..\..\libraries;..\..\Src;..\..\..\..\kernel\F4_UCOSII;..\..\..\..\kernel;..\..\..\..\libraries\mTMC5130Driver;..\..\..\..\libraries\modules;..\..\..\..\libraries\drivers;..\..\..\..\libraries\modules\itf;..\..\..\board_mod
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/ST
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c
  group Application/User
    ./: startup_stm32f407xx.s
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c tempctl_cfg.c voltage_cfg.c ad_signal_cfg.c motor_cfg.c motor_cmd_extend.c
    ../Inc/: project_cfg.h
  group Src
    ../../../../tools/: thread_safe.c async.c delayus.c flash_f4.c
    ../../Src/: my_main.c my_callback.c ad5245.c gpio.c
    ../../../../libraries/Boot/: firmwaeExcute.c
    ../../../board_mod/: voltage.c ad_signal.c motor_thread.c tempctrl_thread.c
  group modules
    ../../../../libraries/Protocols/: CommonHandle.c Protocols.c
    ../../../../libraries/Bus/: bus.c
    ../../../../tools/: pid.c
    ../../../../libraries/modules/itf/: itf_00060000.c itf_00060010.c itf_00060020.c itf_00070000.c itf_00070001.c itf_00070002.c itf_00040000.c itf_00040010.c itf_00010000.c itf_00010010.c itf_00010020 .c itf_00010030 .c itf_00010031.c itf_00010032.c itf_00010040 .c itf_00010050.c itf_00010060.c itf_00010070.c itf_00010071.c itf_00010080.c itf_00010082.c itf_00010083.c itf_01000c30.c itf_00040020.c itf_00040030.c itf_00070003.c itf_00010062.c itf_01000b04.c
    ../../../../libraries/mTMC5130Driver/: mTMC5130Device.c mTMC5130Driver.c
  group drivers
    ../../../../libraries/Bus/: bus_can_f4_hal.c CanDriverPB9.lib
    ../../../../libraries/drivers/: AD7699.c ct7112c.c soft_iic.c ad5304.c ms1112.c
  group tools
    ../../../../libraries/Protocols/: bytesBuffer.c
    ../../../../tools/: tool.c data_struct.c math_util.c
  group kernal
    ../../../../kernel/F4_UCOSII/: os_implement.c F4_UCOS2.lib app_hooks.c
software components: CMSIS:CORE 5.4.0
