# Keil uVision project PowerCtl1002.uvprojx, settings and files
target PowerCtl1002 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PowerCtl1002
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x10000
  c misc: --C99 --no-multibyte-chars
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\Inc\Legacy;..\..\..\..\chips\stm32f4xx\CMSISDevice\Inc;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\libraries;..\..\..\..\tools;..\..\..\..\libraries\Protocols;..\..\..\..\libraries\Driver;..\..\..\..\libraries\Bus;..\..\Src;..\..\..\..\kernel\F4_UCOSII;..\..\..\..\kernel;..\..\hardware;..\..\..\..\libraries\modules;..\..\..\..\libraries\modules\itf;..\..\..\..\libraries\drivers;..\..\..\board_mod;..\..\..\..\chips\stm32f4xx\StdDriver\Inc
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_spi.c
  group Application/User
    ./: startup_stm32f407xx.s
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c uart_cfg.c main.c color_cfg.c io_thread_cfg.c ad_signal_cfg.c my_main.c my_callback.c pc_reboot.c uart_config.c
    ../Inc/: project_cfg.h
  group Src
    ../../Src/: global_func_it.c uart_thread.c
    ../../../../tools/: async.c delayus.c
    ../../../board_mod/: power.c io_thread.c color.c ad_signal.c
  group Modules
    ../../../../libraries/Protocols/: CommonHandle.c Protocols.c io_operation.c
    ../../../../libraries/Bus/: bus.c
    ../../Src/: thread_safe.c
    ../../../../tools/: uart_byte_to_frame.c flash_f4.c
    ../../../../libraries/Boot/: firmwaeExcute.c
    ../../../../libraries/modules/: power_mod.c io_mod.c uart_transpond.c
    ../../../../libraries/modules/itf/: itf_01004000.c itf_00020000.c itf_00020010.c itf_00020030.c itf_00050000.c itf_00000040.c itf_00080010.c itf_00080011.c itf_00080012.c itf_00040020.c itf_00040030.c itf_00030000.c itf_00040000.c itf_00040010.c itf_00040001.c itf_00020001.c itf_00030001.c itf_01000c60.c
  group Drivers
    ../../../../libraries/drivers/: ws2812b.c AD7699.c MS5194T.c
    ../../../../libraries/Bus/: bus_uart3_f4_hal.c bus_uart6_f4_hal.c bus_can_f4_hal.c CanDriverPB9.lib bus_uart5_f4_hal.c
  group Kernal
    ../../../../kernel/F4_UCOSII/: os_implement.c F4_UCOS2.lib app_hooks.c
  group Tool
    ../../../../libraries/Protocols/: bytesBuffer.c
    ../../../../tools/: data_struct.c tool.c
software components: CMSIS:CORE 5.6.0
