# Keil uVision project MotorCtl-46-03-1.0-RB.uvprojx, settings and files
target servoMotor (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MotorCtl-46-03-1.0-RB.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x10000,__TARGET_FPU_SOFTVFP
  c misc: --C99 --diag_suppress=1,177,550 --no-multibyte-chars
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\Inc\Legacy;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\chips\stm32f4xx\CMSISDevice\Inc;..\..\..\..\libraries\Protocols;..\..\..\..\libraries\Driver;..\..\..\..\tools;..\..\..\..\libraries\Bus;..\..\..\..\libraries;..\..\..\..\kernel;..\..\..\..\libraries\modules;..\..\..\..\libraries\modules\itf;..\..\..\..\libraries\drivers;..\..\..\board_mod;..\Src;..\Inc;..\..\src;..\..\src\Rtos\CMSIS-RTOS-INTERFACE;..\..\src\Rtos\CMSIS-RTOS-INTERFACE\ucosii;..\..\src\Rtos\uCOS2\Source\include;..\..\src\Rtos\uCOS2\Ports\ARMClang\ST\M4;..\..\src\ServoMotor\drive;..\..\src\ServoMotor\task;..\..\src\ServoMotor\port;..\..\..\..\libraries\mTMC5130Driver;..\..\..\..\tools\cm_backtrace
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ./: startup_stm32f407xx.s
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c global_func_it.c stm32f4xx_hal_timebase_tim.c
  group CFG
    ../Inc/: project_cfg.h bus_cfg.h
    ../../src/: app_cfg.h os_cfg.h
    ../Src/: servoMotor_CFG.c motor_cfg.c tempctl_cfg.c
  group Drivers/ST
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Src
    ../../../../tools/: thread_safe.c delayus.c
    ../../Src/: my_main.c my_callback.c
    ../../../board_mod/: motor_thread.c
    ../../src/: ad5245.c tempctrl_thread.c gpio.c
  group kernel
    ../../../../kernel/F4_UCOSII/: os_implement.c
    ../../src/Rtos/uCOS2/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../src/Rtos/uCOS2/Ports/ARMClang/ST/M4/: os_cpu_a.s os_cpu_c.c
    ../../src/Rtos/CMSIS-RTOS-INTERFACE/ucosii/: cmsis_os2.c
  group servoMotor
    ../../src/ServoMotor/drive/: TMC4361.c
    ../../src/ServoMotor/task/: servoMotor.c
  group drivers
    ../../../../libraries/Bus/: bus_can_f4_hal.c CanDriverPB9.lib
    ../../../../tools/: flash_f4.c
    ../../../../libraries/drivers/: pb7_43.c
  group modules
    ../../../../libraries/modules/itf/: itf_00070010.c itf_00020010.c itf_00010000.c itf_00010010.c itf_00010020 .c itf_00010030 .c itf_00010031.c itf_00010040 .c itf_00010050.c itf_00010060.c itf_00010070.c itf_00010080.c itf_00010082.c itf_00010032.c itf_00010071.c itf_00010083.c itf_00070000.c itf_00070001.c itf_00070002.c itf_00070011.c itf_01000c10.c itf_000100a0.c itf_000100a1.c itf_000100a2.c itf_00020000.c itf_00020030.c itf_00030000.c itf_00040020.c itf_00040010.c itf_00040030.c itf_00040000.c itf_01000c30.c itf_00070003.c itf_00010062.c itf_01000b04.c itf_01000f10.c itf_00060000.c itf_00060010.c itf_00060020.c
    ../../../../libraries/Protocols/: protoTest.c CommonHandle.c bytesBuffer.c Protocols.c
    ../../../../tools/: data_struct.c uart_byte_to_frame.c
    ../../../../libraries/Bus/: bus.c
    ../../../../libraries/Boot/: firmwaeExcute.c
    ../../../../libraries/modules/: io_mod.c
    ../../../../libraries/mTMC5130Driver/: mTMC5130Device.c mTMC5130Driver.c
  group tools
    ../../../../tools/: math_util.c tool.c pid.c
software components: CMSIS:CORE 5.4.0
