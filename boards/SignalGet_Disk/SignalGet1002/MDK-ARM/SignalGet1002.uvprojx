# Keil uVision project SignalGet1002.uvprojx, settings and files
target SignalGet1002 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SignalGet1002 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x10000
  c misc: --C99 --diag_suppress=1,177,550 --no-multibyte-chars
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\Inc\Legacy;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\chips\stm32f4xx\CMSISDevice\Inc;..\..\..\..\libraries\Protocols;..\..\..\..\libraries\Driver;..\..\..\..\tools;..\..\..\..\libraries\Bus;..\..\..\..\libraries;..\..\Src;..\..\..\..\kernel\F4_UCOSII;..\..\..\..\kernel;..\..\..\..\libraries\mTMC5130Driver;..\..\..\..\libraries\modules;..\..\..\..\libraries\modules\itf;..\..\..\..\libraries\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Drivers/ST
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Src
    ../../Src/: auto_cali_it.c auto_cali_encoder.c auto_cali_client.c cal.c my_main.c my_callback.c AD7699.c signal_det.c ADCDetectHandle.c get_motor_type.c write_data.c itf_137.c
    ../../../../tools/: delayus.c flash_f4.c
    ../../../../libraries/Protocols/: CommonHandle.c
  group kernel
    ../../../../kernel/F4_UCOSII/: os_implement.c F4_UCOS2.lib app_hooks.c
  group drivers
    ../../Src/: spi_driver.lib
    ../../../../libraries/Bus/: CanDriverPB9.lib
  group modules
    ../../../../libraries/Protocols/: bytesBuffer.c Protocols.c
    ../../../../tools/: uart_byte_to_frame.c
    ../../../../libraries/Bus/: bus.c bus_can_f4_hal.c
    ../../../../libraries/Boot/: firmwaeExcute.c
  group tools
    ../../../../tools/: async.c thread_safe.c tool.c data_struct.c
software components: CMSIS:CORE 5.4.0
