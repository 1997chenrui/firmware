# Keil uVision project other.uvprojx, settings and files
target other (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: other +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x00
  c misc: --C99
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\Inc\Legacy;..\..\..\..\arch\cortex-m\CMSIS/Include;..\..\..\..\arch\cortex-m\CMSIS/Device/ST/STM32F4xx/Include;..\..\..\..\libraries\Protocols;..\..\..\..\tools;..\..\..\..\libraries\Bus;..\..\..\..\libraries;..\..\Src;..\..\..\..\kernel;..\..\..\..\libraries;..\..\..\..\libraries\modules;..\..\..\..\kernel\F4_UCOSII;..\Src
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c project_cfg.h
    ../../../../kernel/F4_UCOSII/: app_hooks.c F4_UCOS2.lib
    ../../../../libraries/Bus/: CanDriverPB9.lib
  group Drivers/CMSIS
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Protocols
    ../../../../libraries/Protocols/: CommonHandle.c bytesBuffer.c Protocols.c
  group Bus
    ../../../../kernel/F4_UCOSII/: os_implement.c
    ../../../../tools/: uart_byte_to_frame.c tool.c thread_safe.c data_struct.c
    ../../../../libraries/Bus/: bus.c bus_can_f4_hal.c
  group Src
    ../../Src/: my_main.c
    ../../../../tools/: flash_f4.c async.c delayus.c
    ../../../../libraries/Boot/: boot_loader_callback.c
  group Boot
    ../../../../libraries/Boot/: firmwaeExcute.c
software components: CMSIS:CORE 5.4.0
