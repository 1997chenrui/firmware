# Keil uVision project CellStainingV1-B.uvprojx, settings and files
target CellStainingV1-B (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CellStainingV1-B
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x00000,IS_DEBUG_TMC
  c misc: --C99
  c include: ..\Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\\Inc\Legacy;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\chips\stm32f4xx\CMSISDevice\Inc;..\..\..\..\libraries\Protocols;..\..\..\..\tools;..\..\..\..\libraries\Bus;..\..\..\..\libraries\libraries;..\Src;..\..\..\..\libraries\mTMC5130Driver;..\..\..\..\libraries\Driver;..\..\..\..\kernel;..\..\..\..\libraries;..\..\Hardware;..\..\..\..\libraries\modules;..\..\..\..\kernel\F4_UCOSII;..\..\Src
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Protocols
    ../../../../libraries/Protocols/: io_operation.c Protocols.c bytesBuffer.c CommonHandle.c IOHandle.c protoTest.c
  group Bus
    ../../../../tools/: tool.c data_struct.c
    ../../../../libraries/Bus/: bus_can_f4_hal.c bus.c
    ../../../../kernel/F4_UCOSII/: os_implement.c
  group Tools
    ../../../../tools/: flash_f4.c link_list.c
  group Src
    ../../Src/: my_main.c app_hooks.c my_callback.c
    ../../../../libraries/Boot/: firmwaeExcute.c
    ../../../../libraries/Bus/: CanDriverPB9.lib
    ../../../../tools/: thread_safe.c math_util.c delayus.c
    ../../../../kernel/F4_UCOSII/: F4_UCOS2.lib
  group mTMC5130
    ../../../../libraries/mTMC5130Driver/: mTMC5130Device.c mTMC5130Driver.c mTMC5130MotorHandle.c
    ../../Src/: mTMC5130DThread.c
  group Modules
    ../../../../libraries/modules/: tct_pressure_singal.c io_ctrl_event.c
  group Hardware
    ../../Hardware/: io.c sensor.c
software components: CMSIS:CORE 5.4.0
