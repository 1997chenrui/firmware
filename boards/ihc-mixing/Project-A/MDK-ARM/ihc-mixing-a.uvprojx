# Keil uVision project ihc-mixing-a.uvprojx, settings and files
target ihc-mixing-a (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ihc-mixing-a
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0X10000
  c misc: --C99
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\Inc\Legacy;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\chips\stm32f4xx\CMSISDevice\Inc;..\..\..\mTMC5130Driver;..\..\..\..\libraries\Protocols;..\..\..\..\libraries\Driver;..\..\..\..\tools;..\..\..\..\libraries\Bus;..\..\..\..\libraries;..\mTMC5130;..\..\Src;..\..\..\..\kernel\F4_UCOSII;..\..\..\..\kernel;..\..\..\..\libraries\mTMC5130Driver;..\..\Hardware;..\..\..\..\libraries\modules
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ./: startup_stm32f407xx.s
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Drivers/ST
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c
  group Tool
    ../../../../tools/: data_struct.c tool.c math_util.c flash_f4.c
  group Src
    ../../Src/: thread_safe.c my_main.c taskio_thread.c my_callback.c gpio.c ad5245.c exti.c
    ../mTMC5130/: mTMC5130DThread.c
    ../../Hardware/: dac.c
    ../../../../tools/: delayus.c async.c
  group Modules
    ../../../../libraries/Protocols/: CommonHandle.c bytesBuffer.c Protocols.c IOHandle.c io_operation.c
    ../../../../libraries/Boot/: firmwaeExcute.c
    ../../../../tools/: uart_byte_to_frame.c
    ../../../../libraries/Bus/: bus.c
    ../../../../libraries/mTMC5130Driver/: mTMC5130MotorHandle.c mTMC5130Device.c
    ../../../../libraries/modules/: tct_mixing.c
  group Drivers
    ../../../../libraries/Bus/: bus_can_f4_hal.c CanDriverPB9.lib
    ../../../../libraries/mTMC5130Driver/: mTMC5130Driver.c
  group Kernal
    ../../../../kernel/F4_UCOSII/: os_implement.c app_hooks.c F4_UCOS2.lib
software components: CMSIS:CORE 5.0.1
