# Keil uVision project ihc_route_a.uvprojx, settings and files
target ihc_route_a (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ihc_route_a
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x10000
  c misc: --C99
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\Inc\Legacy;..\..\..\..\chips\stm32f4xx\CMSISDevice\Inc;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\libraries;..\..\..\..\tools;..\..\..\..\libraries\Protocols;..\..\..\..\libraries\Driver;..\..\..\..\libraries\Bus;..\..\Src;..\..\..\..\kernel\F4_UCOSII;..\..\..\..\kernel;..\..\hardware
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group Application/User
    ./: startup_stm32f407xx.s
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c
  group Src
    ../../hardware/: powerled.c color.c
    ../../Src/: global_func_it.c my_main.c my_callback.c taskio_thread.c gpio.c
    ../../../../tools/: async.c delayus.c
    ../../../../libraries/Driver/: TCS_RGB.c
  group Modules
    ../../../../libraries/Protocols/: RGBSensorHandle.c UartTransmitHandle.c CommonHandle.c Protocols.c IOHandle.c io_operation.c
    ../../../../libraries/Bus/: bus.c
    ../../Src/: thread_safe.c
    ../../../../tools/: uart_byte_to_frame.c flash_f4.c uart_transfer.c
    ../../../../libraries/Boot/: firmwaeExcute.c
  group Drivers
    ../../../../libraries/Driver/: TempSensor_DS18B20.c
    ../../../../libraries/Bus/: bus_uart3_f4_hal.c bus_uart6_f4_hal.c bus_can_f4_hal.c CanDriverPB9.lib
    ../../Src/: ws2812b.c
  group Kernal
    ../../../../kernel/F4_UCOSII/: os_implement.c F4_UCOS2.lib app_hooks.c
  group Tool
    ../../../../libraries/Protocols/: bytesBuffer.c
    ../../../../tools/: data_struct.c tool.c
software components: CMSIS:CORE 5.4.0
