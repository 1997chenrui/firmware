# Keil uVision project LED.uvprojx, settings and files
target LED (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: LED +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\UCOSIII\uC-CPU;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB;..\UCOSIII\uC-LIB\Ports;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\Core\Src\OS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Core/Src/OS/: app.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group BSP
    ../Core/Src/OS/: bsp.c bsp.h
  group OS-CFG
    ../Core/Src/OS/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uCOSIII-CPU
    ../UCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uCOSIII-Ports
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOSIII-Source
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_type.h os.h
  group uCOSIII-LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
software components: CMSIS:CORE 4.3.0
