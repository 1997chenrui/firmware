# Keil uVision project EthExample.uvprojx, settings and files
target EthExample (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EthExample +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,PLATFORM_UCOS2,VECT_TAB_OFFSET=0x10000,DEBUG_LOG_LEVEL=4
  c misc: --C99 --no-multibyte-chars --diag_suppress=177
  c include: ../Inc;..\..\..\..\chips\stm32f4xx\Driver\Inc;..\..\..\..\chips\stm32f4xx\Inc\Legacy;..\..\..\..\arch\cortex-m\CMSIS\Include;..\..\..\..\chips\stm32f4xx\CMSISDevice\Inc;..\..\..\..\libraries\Protocols;..\..\..\..\libraries\Driver;..\..\..\..\tools;..\..\..\..\libraries\Bus;..\..\..\..\libraries;..\..\Src;..\..\..\..\libraries\mTMC5130Driver;..\..\..\..\libraries\modules;..\..\..\..\libraries\drivers;..\..\..\..\libraries\modules\itf;..\..\..\board_mod;..\..\..\..\libraries\oldProtocols;..\..\..\mod;..\..\..\..\chips\stm32f4xx\mod;..\..\..\..\chips\stm32f4xx\mod\ETHERNET_NOSYS;..\..\..\..\libraries\drivers\softiic;..\..\..\mod\uart_transmit;..\..\..\..\kernel\uCOS2\Source\include;..\..\..\..\kernel\uCOS2\Ports\ARMClang\ST\M4;..\..\..\..\kernel\CMSIS-RTOS-INTERFACE\ucosii;..\..\..\..\kernel\CMSIS-RTOS-INTERFACE;..\..\..\..\kernel;..\..\..\..\third_party\lwip-2.1.3\src\include;..\..\..\..\third_party\lwip-2.1.3\src\include\compat;..\..\..\..\third_party\lwip-2.1.3\src\include\lwip;..\..\..\..\third_party\lwip-2.1.3\src\include\netif;..\..\..\..\third_party\lwip-2.1.3\src\include\lwip\apps;..\..\..\..\third_party\lwip-2.1.3\src\include\lwip\priv;..\..\..\..\third_party\lwip-2.1.3\src\include\lwip\prot;..\..\..\..\third_party\lwip-2.1.3\arch\stm32F4NoSYS
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/ST
    ../../../../chips/stm32f4xx/CMSISDevice/Src/Templates/: system_stm32f4xx.c
    ../../../../chips/stm32f4xx/Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_eth.c
  group Application/User
    ../Src/: my_main.c my_callback.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c io.c uart_cfg.c
    ./: startup_stm32f407xx.s
    ../Inc/: project_cfg.h app_cfg.h os_cfg.h stm32f4xx_hal_conf.h eth_cfg.h
  group modules
    ../../../../libraries/modules/itf/: itf_00020000.c itf_00020010.c itf_00020030.c itf_00020001.c itf_00030001.c itf_00030000.c itf_00050000.c itf_00020050.c itf_00030010.c itf_00030020.c
    ../../../../libraries/modules/: bus.c uart_transpond.c io_mod.c
    ../../../../chips/stm32f4xx/mod/ETHERNET_NOSYS/: ethernet_F4.c udpTOCan_RAW.c
  group oldProtocols
    ../../../../libraries/oldProtocols/: CommonHandle.c Protocols.c firmwaeExcute.c bytesBuffer.c
  group drivers
    ../../../../chips/stm32f4xx/mod/: bus_can_f4_hal.c CanDriverPB9.lib flash_f4.c delayus.c
  group tasks
    ../../../mod/uart_transmit/: uart_transmit.c
    ../../../mod/: io_thread.c
  group tools
    ../../../../tools/: thread_safe.c tool.c data_struct.c
  group kernal
    ../../../../kernel/F4_UCOSII/: os_implement.c
    ../../../../kernel/uCOS2/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../../../kernel/uCOS2/Ports/ARMClang/ST/M4/: os_cpu_a.s os_cpu_c.c
    ../../../../kernel/CMSIS-RTOS-INTERFACE/ucosii/: cmsis_os2.c
  group lWIP/arch
    ../../../../third_party/lwip-2.1.3/arch/stm32F4NoSYS/: cc.h ethernetif.c ethernetif.h lwipopts.h perf.h
  group lWIP/api
    ../../../../third_party/lwip-2.1.3/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lWIP/core
    ../../../../third_party/lwip-2.1.3/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../third_party/lwip-2.1.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lWIP/netif
    ../../../../third_party/lwip-2.1.3/src/netif/: ethernet.c
software components: CMSIS:CORE 5.4.0
